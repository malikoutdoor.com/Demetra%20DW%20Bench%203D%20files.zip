Properties of the parts of a building model (IFC2X3)

# File
Description: ViewDefinition [CoordinationView_V2.0, QuantityTakeOffAddOnView]
File name: 0001
Time: 2023-10-31T14:43:36
Written by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013
Made in: 20180423_1000(x64) - Exporter 18.3.1.2 - Alternate UI 18.3.1.2
Comment: STEP Physical File produced by: The EXPRESS Data Manager Version 5.02.0100.07 : 28 Aug 2013 * Module: EDMstepFileFactory/EDMstandAlone * Creation date: Tue Oct 31 14:43:36 2023 * Host: LAPTOP-RP8DN0OA * Database: C:\Users\claud\AppData\Local\Temp\{287509BE-0193-4B4A-BCC6-DFE82506140C}\ifc * Database version: 5507 * Database creation date: Tue Oct 31 14:43:35 2023 * Schema: IFC2X3 * Model: DataRepository.ifc * Model creation date: Tue Oct 31 14:43:35 2023 * Header model: DataRepository.ifc_HeaderModel * Header model creation date: Tue Oct 31 14:43:35 2023 * EDMuser: sdai-user * EDMgroup: sdai-group * License ID and type: 5605 : Permanent license. Expiry date: * EDMstepFileFactory options: 020000

# IfcProject, 0001
LongName: Nome; Phase: Stato

# IfcSite, Default
RefLatitude: 41, 47, 59, 997253; RefLongitude: 12, 36, 0, 1373; RefElevation: 0 m
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuilding
Pset_BuildingCommon - NumberOfStoreys: 1
Altro - Categoria: Informazioni sul progetto; Data di consegna del progetto: Data; Nome del cliente: Proprietario; Nome del progetto: Nome; Numero del progetto: 0001; Stato del progetto: Stato

# IfcBuildingStorey, 0 - Piano Terra
LongName: 0 - Piano Terra; Elevation: 0 m
Vincoli(Type) - Base quota altimetrica: Punto base progetto
Grafica(Type) - Colore: 0; Modello di linea: Tratto; Simbolo: Estremità Livello: Triangolo; Simbolo a estremità 1 per default: no; Simbolo a estremità 2 per default: yes; Spessore di linea: 1
Altro - Categoria: Livelli; Famiglia: Livello: Livello; Famiglia e tipo: Livello: Livello; ID tipo: Livello: Livello; Tipo: Livello: Livello
Dati identità - Nome: 0 - Piano Terra; Piano edificio: yes; Strutturale: no
Dimensioni - Altezza di calcolo: 0 m
Vincoli - Quota altimetrica: 0 m
Altro(Type) - Categoria: Livelli; Nome famiglia: Livello
Dati identità(Type) - Nome del tipo: Livello

# IfcBuildingElementProxy: 0PAAR158 - WITHOUT LEVELLING - VERDE ALPI, Panca DEMETRA DW:0PAAR158 - WITHOUT LEVELLING - VERDE ALPI:168284
In: 0 - Piano Terra
Type - Material: CONIFERA, VERDE ALPI
Type - Altro - Categoria: Modelli generici; Nome famiglia: Panca DEMETRA DW
Type - Dati identità - BIM Name: DEMETRA DW SENZA LIVELLAMENTO; BIM Object Type: PANCHINE - BENCHES; Code: 0PAAR158; Designer: BELLITALIA DESIGN; Family Name: DEMETRA; Nome del tipo: 0PAAR158 - WITHOUT LEVELLING - VERDE ALPI; URL Eng: https://www.bellitalia.net/en/products/benches/demetra-d/; URL Ita: https://www.bellitalia.net/prodotti/panchine/demetra-d/
Type - Dimensioni - Dimensions: 1800 mm X 600 mm X 480 mm
Type - Generale - Descrizione Tecnica Famiglia: "Panca lineare modulare mod. “DEMETRA” DW costituita da una seduta monolitica con seduta singola integrata in legno, così da essere confortevole sia in climi caldi che freddi."; Descrizione Tecnica per Codice: PANCA DEMETRA DW SENZA LIVELLAMENTO IN VERDE ALPI SABBIATO CON PIANO DI SEDUTA BOCCIARDATO VERNICIATURA ANTI-DEGRADO E SEDUTA IN LEGNO DI CONIFERA; Fissaggio: Appoggio; Fixings: Freestanding; Technical Description Family: "Modular linear bench mod. “DEMETRA” DW consisting of a monolithic seat with single seat integrated in wood, so as to be comfortable in both hot and cold climates."; Technical Description for Article: DEMETRA DW WITHOUT LEVELLING SYSTEM BENCH IN GREEN ALPS SANDBLASTED WITH BUSH-HAMMERED SEAT SURFACE ANTI-DECAY VARNISH AND CONIFER WOOD SEAT
Type - Materiali e finiture - Materiale Principale: Pietre Preziose Ricostituite Verde Alpi; Materiale Secondario: Pietre Preziose Ricostituite; Legno Conifera; MATERIALE SEDUTA: CONIFERA; MATERIALE SUPPORTO: VERDE ALPI; Primary Material: Green Alps Reconstituted Precious Stones; Secondary Material: Reconstituted Precious Stone; Coniferous wood
Type - Meccanica - Weight ( kg): 1155 Kg
Pset_BuildingElementProxyCommon - Reference: 0PAAR158 - WITHOUT LEVELLING - VERDE ALPI
Altro - Famiglia: Panca DEMETRA DW: 0PAAR158 - WITHOUT LEVELLING - VERDE ALPI; Famiglia e tipo: Panca DEMETRA DW: 0PAAR158 - WITHOUT LEVELLING - VERDE ALPI; ID tipo: Panca DEMETRA DW: 0PAAR158 - WITHOUT LEVELLING - VERDE ALPI; Tipo: Panca DEMETRA DW: 0PAAR158 - WITHOUT LEVELLING - VERDE ALPI
Dimensioni - Area: 3.86546 m2; Volume: 0.47884 m3
Fasi - Fase di creazione: Stato di Progetto
Vincoli - Host: Livello : 0 - Piano Terra; Livello: Livello: 0 - Piano Terra; Offset: 0 m; Sposta con l'oggetto più vicino: no
